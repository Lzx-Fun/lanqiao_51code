# Keil uVision project 51project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 51project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\driver
  group Source Group 1
    ./: main.c
    ./driver/: led.c exti.c timer.c seg.c key.c uart.c ds1302.c ds18b20.c iic.c PCF8591.c at24c02.c ultrasonic.c
